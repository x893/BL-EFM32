# Keil uVision project app-G880.uvprojx, settings and files
target app-G880 (ARM-ADS)
  device: EFM32G880F128 Energy Micro
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M3") CLOCK(32000000) ELITTLE
  output: app-G880
  c flags: Optim=1 OneElfS=1
  c define: EFM32G880F128
  c include: ..\emlib\inc;..\Device\EnergyMicro\EFM32G\Include
  library: MicroLIB
  memory RVCT4: ROM 0x800 size 0x1f800
  memory RVCT9: RAM 0x20000000 size 0x4000
  group app
    ../: startup_efm32g.s system_efm32g.c app.c
  group emlib
    ../emlib/src/: em_leuart.c em_gpio.c em_cmu.c em_emu.c
