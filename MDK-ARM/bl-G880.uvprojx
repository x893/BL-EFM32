# Keil uVision project bl-G880.uvprojx, settings and files
target bl-G880 (ARM-ADS)
  device: EFM32G880F128 Energy Micro
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M3") CLOCK(32000000) ELITTLE
  output: bl-G880
  c flags: Optim=4 OneElfS=1
  c define: EFM32G880F128
  c include: ..\emlib\inc;..\Device\EnergyMicro\EFM32G\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x800
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\bl-G880.sct
  group Demo
    ../: main.c system_efm32g.c startup_efm32g.s
  group emlib
    ../emlib/src/: em_system.c em_cmu.c em_emu.c em_gpio.c em_leuart.c em_msc.c
